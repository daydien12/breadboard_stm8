# IAR project breadboard_stm8.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\library; ..\USER
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: breadboard_stm8.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Json
    ../USER/: tiny-json.c tiny-json.h
  group lib
    ../library/: stm8s.h stm8s_conf.h stm8s_gpio.c stm8s_gpio.h stm8s_it.c stm8s_it.h
  group user
    ../USER/: Config_GPIO.c Config_GPIO.h Define.h DELAY.c DELAY.h main.c SYS.c SYS.h uart.c uart.h
