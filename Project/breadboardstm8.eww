<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\breadboard_stm8.ewp</path>
    </project>
    <project>
        <path>E:\1.STM8\3.project_STM8S103F3P6\0.Test\project\test.ewp</path>
    </project>
    <batchBuild />
</workspace>
